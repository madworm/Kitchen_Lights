# Repository madworm/Kitchen_Lights

File README.md:

Kitchen_Lights
==============

LAYOUT FILES: ATtiny24 /ATtiny2313 + MBI5168 controlled lamp with 32x 0.5W straw-head LEDs.

---

Before having PC-boards made, please make sure you know about your manufacturer's peculiarities!
Especially drill-sizes and their tolerances may vary too much and give you trouble.

## KiCad design kitchen_lights.kicad_pcb

Parts:
C1, C3: 100nF
C2, C4, C5, C6: 10muF
C7, C8: 1mF
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED
D33: LED_GREEN
D34, D35: LED_ORANGE
D36: LED RED
D37: LED GREEN
D38: LED BLUE
DS1, DS2: DIODESCH
IC1: MADW__ATTINY2313DIP/SO
IC2: MBI5168
IC3: 7805MS
JP1: ISP
JP2: R/T loop
MH0, MH1, MH2, MH3, MH4, MH5: CONN_1
P1, P2: CONN_8X2
R1: 10k
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 1k
R18, R19, R20, R21, R22, R23: 470
RV1: I_REF
SW1, SW2, SW3: LPH_SW

Connections:
/CLOCK: IC2.3 (CLK), JP1.3 (SCK), P1.7, P2.7, R17.1
/D01_02: D1.4, D2.3
/D02_03: D2.4, D3.3
/D03_04: D3.4, D4.3
/D05_06: D5.4, D6.3
/D06_07: D6.4, D7.3
/D07_08: D7.4, D8.3
/D09_10: D9.4, D10.3
/D10_11: D10.4, D11.3
/D11_12: D11.4, D12.3
/D13_14: D13.4, D14.3
/D14_15: D14.4, D15.3
/D15_16: D15.4, D16.3
/D17_18: D17.4, D18.3
/D18_19: D18.4, D19.3
/D19_20: D19.4, D20.3
/D21_22: D21.4, D22.3
/D22_23: D22.4, D23.3
/D23_24: D23.4, D24.3
/D25_26: D25.4, D26.3
/D26_27: D26.4, D27.3
/D27_28: D27.4, D28.3
/D29_30: D29.4, D30.3
/D30_31: D30.4, D31.3
/D31_32: D31.4, D32.3
/DATA/MISO: IC2.2 (SDI), JP1.1 (MISO), P1.5, P2.5, R16.1
/ENABLE: IC2.13 (OE), P1.11, P2.11, R13.1
/LATCH: IC2.4 (LE), P1.9, P2.9, R14.1
/MOSI: JP1.4 (MOSI), P1.3, P2.3, R15.1
/OUT0: D16.1, IC2.5 (OUT0)
/OUT1: D12.1, IC2.6 (OUT1)
/OUT2: D8.1, IC2.7 (OUT2)
/OUT3: D4.1, IC2.8 (OUT3)
/OUT4: D32.1, IC2.9 (OUT4)
/OUT5: D28.1, IC2.10 (OUT5)
/OUT6: D24.1, IC2.11 (OUT6)
/OUT7: D20.1, IC2.12 (OUT7)
/PB0: P1.8, P2.8, R10.1
/PB1: P1.10, P2.10, R11.1
/RESET: IC1.1 (PA2_(RESET)), JP1.5 (RST), R1.2
/RXI: JP2.1, P1.1, P2.1, R3.1
/RX_LED: P1.12, P2.12, R12.1
/RX_LED_i: IC1.14 ((OC0A/PCINT2)_PB2), R12.2, R19.1
/SW1: R5.1, SW1.3
/SW2: R6.1, SW2.3
/SW3: R7.1, SW3.3
/S_LED: P1.4, P2.4, R8.1
/S_LED_i: IC1.9 ((OC0B/T1)_PD5), R8.2, R18.1
/TXO: JP2.2 (PM), P1.2, P2.2, R4.1
/TX_LED: P1.6, P2.6, R9.1
/TX_LED_i: IC1.11 ((ICP)_PD6), R9.2, R20.1
GND: C1.2, C2.2, C6.2, D33.2 (K), D34.2 (K), D35.2 (K), IC1.10 (GND), IC3.2 (GND), IC3.3 (GND), JP1.6 (GND), RV1.3, SW1.2, SW2.2, SW3.2
GNDPWR: C3.2, C4.2, C5.2, C7.2, C8.2, IC2.1 (GND), IC3.6 (GND), IC3.7 (GND), P1.13, P1.14, P2.13, P2.14
unnamed: D33.1 (A), R18.2
unnamed: R21.1, SW1.4
unnamed: IC1.17 ((MOSI/DI/SDA/PCINT5)_PB5), R15.2
unnamed: IC1.19 ((USCK/SCK/PCINT7)_PB7), R17.2
unnamed: IC1.2 ((RXD)_PD0), R3.2
unnamed: IC1.6 ((CKOUT/XCK/INT0)_PD2), R5.2
unnamed: IC1.8 ((T0)_PD4), R7.2
unnamed: IC1.13 ((AIN1/PCINT1)_PB1), R11.2
unnamed: IC1.15 ((OC1A/PCINT3)_PB3), R13.2
unnamed: IC2.15 (R-EXT), RV1.2
unnamed: D37.2 (K), R22.2
unnamed: D35.1 (A), R20.2
unnamed: D34.1 (A), R19.2
unnamed: D38.2 (K), R23.2
unnamed: R22.1, SW2.4
unnamed: D36.2 (K), R21.2
unnamed: IC1.3 ((TXD)_PD1), R4.2
unnamed: IC1.7 ((INT1)_PD3), R6.2
unnamed: IC1.18 ((MISO/DO/PCINT6)_PB6), R16.2
unnamed: IC1.16 ((OC1B/PCINT4)_PB4), R14.2
unnamed: R23.1, SW3.4
unnamed: IC1.12 ((AIN0/PCINT0)_PB0), R10.2
VCC: C1.1, C2.1, C3.1, C4.1, C6.1, D36.1 (A), D37.1 (A), D38.1 (A), IC1.20 (VCC), IC2.16 (VDD), IC3.1 (VOUT), JP1.2 (VTG), R1.1

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
Board: 2 copper layers, 273.6 x 36.8 mm, 93 parts (11 on the bottom side), 77 nets.

Other parts of the board:
G1, G2, G7, G8: LOGO
G3, G4, G5, G6: LOGO

## Commit log

2011-03-05 Initial commit Added the footprints for the TopBright 'Straw Head' LEDs.
2011-03-05 Polarity of the LED pins was reversed...
2011-03-15 Might be ready for a first prototype soon.
2011-03-15 kicad is driving me nuts... the friggin' design rules...
2011-03-15 Fixed a few things here and there. Hope I got all of it.
    I hate the footprint mess in KiCAD. No footprint browser...
2011-03-15 Fixed a library path.
    Kicad always deleted my symlinks and recreated the files.
2011-03-16 Silkscreen cosmetics.
2011-03-16 Copper pour insanity !
    Had the front fill as V_led and the back as GNDPWR.
    Unfortunately the mounting holes are plated... Might cause a short
    if the bolts are tightened too hard. Now the front fill is disconnected.
2011-03-19 Upgrades... added a small prototyping area for the remaining pins.
2011-03-20 Silkscreen fixes.
2011-03-21 Found a solder mask clearance issue.
    The clearance was set to 8 (or 10?) mils. A strange diagonal trace
    could have been exposed... ;-(
    Now the solder mask clearance is set to 4mils, which is half the
    minimum trace clearance.
2011-04-24 Added my 'purple pcb mockup' .gvp file.
2011-04-24 Added a small pcb for the 2200µF capacitors to kill the LED 'breathing'.
2011-05-04 Added some info for the 'capacitor_board'.
2011-05-04 Reworked the board, now calling it 'V1.01'.
2011-05-04 Added a shell script for easier pushing to all repos.
2011-05-04 Added 'BestKitchenLightsEver(tm)' as the title and 'My 2µF Blog'.
2011-05-04 Some reworking...
2011-07-29 Routed the V1.10 board. Still some silkscreen issues.
2011-07-29 Re-arranged the ATtiny2313 to let the MBI5168 have less vias.
2011-07-29 Updated the push-script.
2011-07-30 Switched to high efficiency Nichia superflux leds.
2011-07-30 Used smaller electrolytics + 0603 resistors = smaller board.
2011-07-30 Fixed silkscreen + routing issues.
2011-07-30 Added a whole lot of 0805 leds for status etc...
2011-07-31 Fixed silkscreen issues again + moved mounting holes around a bit.
2011-08-01 Fixed: text was on back copper layer instead of back silkscreen.
2011-08-12 Added the 'open source hardware' logo to the silkscreen.
2011-08-12 Copied the OSHW_logo folder to here. So I won't need an extra repo.
2011-08-12 Small bug fix for the 'usage' text.
2011-08-12 Fixed: number of accepted digits.
2011-08-12 Fixed a typo.
2011-08-12 Added a few pre-scaled OSHW logos for convenience (1-20mm).
2011-08-13 Moved the ARGC check to the very beginning.
2011-08-20 Updated the silkscreen. Added the vectorized smiley logo.
2011-08-21 Layout fixes:
    * Changed a few auto-routed traces to get better isolation from pads.
    Avoids mask clearance issues.
    * Moved most of the LEDs on the right side about 10mil around to match
    the ones on the left side. As much as I hate math, symmetry is nice.
    * DRC check was OK.
2011-08-22 Schottky diode: 32mil is too small. --> upped to 40mil in the board.
    * The footprint "diodesch" should be fixed as well I think.
    Maybe the PCB fab didn't compensate for plating?
    * The prototype boards have arrived. The package was damaged...
    See commit 71fd18cb7af674d5111a8e39b65d14b631ef5e25 for the files
    that were used for these boards!
2011-08-22 HOPEFULLY fixed the FRIGGIN' ISP header for good. 100$ of smoke ;-(
2011-08-22 Forgot to up the schematic/board version to V1.11
2011-08-23 Added a 3D shape to D33.
2011-08-29 Removed the Schottky diodes + trace cleanup.
2011-09-02 Cleaned up some tracks.
2011-09-08 Trace cleanup.
2011-10-05 Added a .pdf file with the schematic.
2011-10-08 Corrected some .gvp files due to folder renaming.
2012-04-03 Updated 'scale.sh' to accept a layer number for the logo.
2012-04-03 Updated 'readme.txt' with the new layer setting.
2012-04-03 Removed the gitorious stuff from 'push.sh'
2012-04-03 Layer was swapped.
2012-05-30 Upgraded the OSHW_logo folder.
2012-06-02 Finally added .gitignore to the repo.
2012-06-02 Removed files now covered by .gitignore
2012-06-02 Updated .gitignore
2012-09-03 Cleaned up the .gvp files...
2012-12-10 Removed OSHW_logo folder.
    Get it at http://oshwlogo.com
2013-01-17 Added README.md
2013-01-24 Renamed stuff. KiCad changed layer names for gerber export a while ago.
2013-06-28 Converted to new kicad board format.
2014-06-25 Moved a .gvp file to right location.
